## boards/shields/meteorite40_low/Kconfig.defconfig
```kconfig
if SHIELD_METEORITE40_LOW

config ZMK_KEYBOARD_NAME
    default "meteorite40_low"
endif
```
